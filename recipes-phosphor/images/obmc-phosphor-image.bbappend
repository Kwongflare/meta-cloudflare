CORE_IMAGE_EXTRA_INSTALL += "openssh"
PACKAGE_EXCLUDE += " packagegroup-core-ssh-dropbear"

